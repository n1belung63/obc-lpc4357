# Keil uVision project m4f.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.10.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: m4f +hex
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=9 v6Lto=1 wLevel=4
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x10080000 size 0x8000
  group System
    ./: main.cpp board.cpp board.h board_settings.h config.h
    ./singelton/: singelton.h
  group RtosWrapper
    ./rtos_wrapper/: rtosdefs.h freertos_wrapper.h rtos.cpp rtos.h task_wrapper.h semphr_wrapper.h
  group Drivers
    ./drivers/: mpu9250_driver.h sdhc_driver.h pca9554_driver.h
  group InterfaceDrivers
    ./wrappers/: uart_wrapper.h i2c_wrapper.h spi_wrapper.h
  group System Abstraction
    ./system_abstraction/: board_api.h data_storage_config.h
    ./pool-allocator/: pool_allocator_port_api.h
  group Application
    ./application/: data_storage.h
    ./pool-allocator/: pool_allocator.h pool_allocator_port.h
  group Tasks
    ./tasks/: data_acquisition_task.h uart_task.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Heap 10.3.1, CMSIS:CORE 5.4.0, CMSIS Driver:I2C 2.8, CMSIS Driver:SPI:SSP 2.12, CMSIS Driver:USART 2.17, Device:GPDMA 1.6, Device:GPIO 1.1, Device:SCU 1.2, Device:Startup 1.0.0
